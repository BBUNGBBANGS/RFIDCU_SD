# IAR project RFIDCU_App.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F105RC ST STM32F105RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RFIDCU_V114_20220804.bin
  ILINK.IlinkOutputFile: RFIDCU_Stm32f10x_App.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group EWARMv7.7
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl78.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../: AppLog.c AppMain.c CAN.c Common.c CpuRtc.c CpuRtc.h crc.c eeprom.c FlashMem.c Front.c grf.c main.c MicroSD.c MyTag.c MyTpu.c rfcom.c rfid.c stm32f10x_it.c system_stm32f10x.c util.c
